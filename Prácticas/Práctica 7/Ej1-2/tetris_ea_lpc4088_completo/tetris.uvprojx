# Keil uVision project tetris.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tetris
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bloque.c cuveta.c font_8x16.c font_12x24.c font_16x32.c glcd.c joystick.c juego.c leds.c main.c marcador.c menu.c pieza.c sdram.c tablero.c timer0.c timer1.c error.c gpio_lpc40xx.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
